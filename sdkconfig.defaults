## sdkconfig.defaults
```kconfig
# Stack maior para HTTP + JSON
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8192

# Log level
CONFIG_LOG_DEFAULT_LEVEL_INFO=y

# SNTP
CONFIG_LWIP_SNTP_MAX_SERVERS=1
```
